# Repository tuton-RCJ/RCJ2026PCB

File README.md:

# RCJ2026PCB
PCBs for RoboCupJunior 2026 Maze

## KiCad design 01-kanto/04-RPi/04-RPi.kicad_pcb

Parts:
J1: BOTTOM; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: RPi; PinSocket_2x20_P2.54mm_Vertical
J9: RPi; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical

Connections:
+5V: J1.1, J2.2, J2.4, J9.1
BOTTOM_RX: J1.2, J2.32
BOTTOM_TX: J1.3, J2.33
GND: J1.4, J2.6, J2.9, J2.14, J2.20, J2.25, J2.30, J2.34, J2.39, J9.6
LiDAR_RX: J2.24, J9.5
LiDAR_TX: J2.21, J9.4
MAIN_RX: J2.27, J9.2
MAIN_TX: J2.28, J9.3

Board: 2 copper layers, 14.0 x 54.0 mm, 3 parts (1 on the bottom side), 8 nets.

File 01-kanto/04-RPi/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
J1,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,BOTTOM,
J2,PinSocket_2x20_P2.54mm_Vertical,1,RPi,
J9,JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,1,RPi,

## KiCad design 01-kanto/01-MAIN/01-MAIN.kicad_pcb

Parts:
BT1: Battery; SolderWire-0.75sqmm_1x02_P7mm_D1.25mm_OD3.5mm
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1: 4n7; C_0402_1005Metric; LCSC C1538
C2, C3, C4, C5, C6, C7, C9, C10, C16, C17: 100n; C_0402_1005Metric; LCSC C1525
C8: 4.7u; C_0402_1005Metric; LCSC C23733
C11, C15, C18, C23: 10u; C_0805_2012Metric; LCSC C15850
C12, C19, C24: 10n; C_0402_1005Metric; LCSC C15195
C13, C20, C25: 220u; CP_Radial_D6.3mm_P2.50mm
C14, C21, C22: 22u; C_0805_2012Metric; LCSC C45783
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D10, D13, D14: SS34; D_SMA; LCSC C8678
D11: LED_GREEN; LED_0805_2012Metric; LCSC C2297
D12: LED_YELLOW; LED_0805_2012Metric; LCSC C2296
F1: 10A; FUSE_3557-15
J1: LiDAR; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J2: CAM_L; Grove_1x04
J3: CAM_R; Grove_1x04
J4: CAM_LED_L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J5: CAM_LED_R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J6: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC C2765186
J7, J12: STS3032_F; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J8, J13: STS3032_B; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J9: RPi; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J10: Loadcell_L; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J11: Loadcell_R; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J14: MG90S_L; PinHeader_1x03_P2.54mm_Horizontal
J15: MG90_R; PinHeader_1x03_P2.54mm_Horizontal
J16: Victim_LED; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L1, L2, L3: 22uH; FXL1040-220-M; LCSC C177244
MES1: Voltmeter_DC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q1, Q2, Q3, Q5: Q_PMOS_GDS; TO-251-3_Vertical
Q6: NPN; SOT-23; LCSC C7420356
Q7: PNP; SOT-23; LCSC C41375129
R1, R2: 100k; R_0402_1005Metric; LCSC C25741
R3: 13k; R_0603_1608Metric; LCSC C22797
R4: 1k8; R_0603_1608Metric; LCSC C4177
R5, R7, R10, R12, R13, R14, R18, R36, R38, R39, R43: 10k; R_0402_1005Metric; LCSC C25744
R11, R15, R19, R37, R42: 2k2; R_0402_1005Metric; LCSC C25879
R16: 7k5; R_0603_1608Metric; LCSC C23234
R17: 20k; R_0402_1005Metric; LCSC C25765
R20: 1k2; R_0603_1608Metric; LCSC C22765
R21: 1k; R_0402_1005Metric; LCSC C11702
R22, R30, R31, R32, R33: 330; R_0402_1005Metric; LCSC C25104
R23: 10; R_0402_1005Metric; LCSC C25077
R24, R26: 5.1k; R_0402_1005Metric; LCSC C25905
R25, R27: 470; R_0603_1608Metric; LCSC C23179
R28, R29, R34, R35: 1M; R_0402_1005Metric; LCSC C26083
R40: 2.7k; R_0603_1608Metric; LCSC C13167
SW1: SW_SPST; AkizukiSmallRockerSwitchHorizontal
SW2, SW6, SW7: SW_Push; SW_PUSH_6mm
SW5: SW_SPDT; Akizuki_3PSW
U1: M51957B
U2: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U4, U10, U12: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias; LCSC C9864
U5: SSD1306
U6: OKL-T/6-W12N-C; OKL-T6-W12N-C-SMD
U7: BNO055
U8: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652
U9: LM358; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm; LCSC C7950
U11: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C22.1, J10.4, J11.4, R7.1, R10.1, R13.2, R14.2, SW7.1, U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U5.2 (VCC), U7.1 (VIN), U9.8 (V+), U11.2 (VO)
+5V: C10.2, C15.1, C16.2, C21.1, D2.1 (VDD), J1.1, J2.3, J3.3, J4.1, J5.1, J9.1, J16.1, Q7.1 (C), R15.1, R20.1, U2.8 (VCC), U6.4 (Vout), U6.5 (Sense), U8.7 (VCC), U11.3 (VI)
BOOT0: R12.1, SW7.2, U3.60 (BOOT0)
BOOT1: R38.1, U3.28 (PB2)
Buzzer: BZ1.1 (+), U3.61 (PB8)
CAM_LED_L: J4.2, U3.41 (PA8)
CAM_LED_R: J5.2, U3.57 (PB5)
D+: J6.A6 (D+), J6.B6 (D+), U8.1 (UD+)
D-: J6.A7 (D-), J6.B7 (D-), U8.2 (UD-)
GND: BT1.2 (-), BZ1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C25.2, D2.3 (VSS), D10.2 (A), D13.2 (A), D14.2 (A), J1.3, J2.4, J3.4, J4.3, J5.3, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J7.3, J8.3, J9.6, J10.1, J11.1, J12.3, J13.3, J14.3, J15.3, J16.3, MES1.1 (-), Q5.1 (G), Q6.3 (E), R1.2, R4.2, R11.2, R12.2, R17.2, R19.2, R20.2, R23.2, R24.1, R25.2, R26.1, R27.2, R29.2, R34.2, R37.2, R38.2, R40.2, SW1.1 (A), SW2.2, SW5.3 (C), SW6.1, U1.4 (GND), U2.5 (GND), U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U4.6 (GND), U4.9 (GNDPAD)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
LED: D2.4 (DIN), U3.49 (PA14)
LiDAR_RX: J1.4, J9.5
LiDAR_TX: J1.2, J9.4
Loadcell_L: R28.2, U3.4 (PC15), U9.1
Loadcell_R: R35.2, U3.50 (PA15), U9.7
MG90S_L: J14.1, U3.40 (PC9)
MG90S_R: J15.1, U3.62 (PB9)
NRST: C9.1, SW6.2, U3.7 (NRST)
unnamed: BT1.1 (+), F1.1
unnamed: C12.2, D10.1 (K), L1.1, U4.8 (PH)
unnamed: D11.2 (A), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)
unnamed: D11.1 (K), R25.1
unnamed: D12.2 (A), U8.6 (TNOW)
unnamed: D12.1 (K), R27.1
unnamed: C19.2, D13.1 (K), L2.1, U10.8 (PH)
unnamed: C24.2, D14.1 (K), L3.1, U12.8 (PH)
unnamed: J6.A5 (CC1), R26.2
unnamed: J6.B5 (CC2), R24.2
unnamed: C13.1, J7.2, J8.2, L1.2, R18.1
unnamed: J10.2, R30.1
unnamed: J10.3, R31.1
unnamed: J11.2, R32.1
unnamed: J11.3, R33.1
unnamed: C20.1, J12.2, J13.2, L2.2, R36.1
unnamed: C25.1, J14.2, J15.2, L3.2, R39.1
unnamed: Q1.2 (D), Q2.2 (D)
unnamed: Q1.1 (G), Q2.1 (G), R2.2, SW1.2 (B)
unnamed: Q1.3 (S), Q3.3 (S), R3.1, R5.1, R42.1, U1.7 (VIN)
unnamed: Q2.3 (S), Q5.3 (S), R2.1
unnamed: Q3.1 (G), Q6.1 (C), R42.2
unnamed: F1.2, Q5.2 (D), R1.1
unnamed: Q6.2 (B), R43.2
unnamed: Q7.2 (B), R16.1
unnamed: Q7.3 (E), R17.1, U2.2 (~RE), U2.3 (DE)
unnamed: R21.2, R22.1
unnamed: R22.2, R23.1
unnamed: C1.1, U1.5 (Cd)
unnamed: R3.2, R4.1, U1.2 (IN)
unnamed: R5.2, R43.1, U1.6 (OUT)
unnamed: R11.1, R15.2, U2.7 (B)
unnamed: C12.1, U4.1 (BOOT)
unnamed: R18.2, R19.1, U4.4 (VSENSE)
unnamed: R21.1, U6.6 (Trim)
unnamed: C17.1, U8.10 (V3)
unnamed: R29.1, R30.2, U9.3 (+)
unnamed: R28.1, R31.2, U9.2 (-)
unnamed: R32.2, R34.1, U9.5 (+)
unnamed: R33.2, R35.1, U9.6 (-)
unnamed: C19.1, U10.1 (BOOT)
unnamed: R36.2, R37.1, U10.4 (VSENSE)
unnamed: C24.1, U12.1 (BOOT)
unnamed: R39.2, R40.1, U12.4 (VSENSE)
SCL: R13.1, U3.58 (PB6), U5.3 (SCL), U7.4 (SCL)
SDA: R14.1, U3.59 (PB7), U5.4 (SDA), U7.3 (SDA)
STS_SIG: J7.1, J8.1, J12.1, J13.1, U2.6 (A)
SW1: R7.2, SW2.1, U3.46 (PA13)
SW2: R10.2, SW5.2 (B), U3.45 (PA12)
UART1_RX: U3.43 (PA10), U8.8 (TXD)
UART1_TX: U3.42 (PA9), U8.9 (RXD)
UART2_RX: J9.2, U3.17 (PA3)
UART2_TX: J9.3, U3.16 (PA2)
UART3_RX: U2.1 (RO), U3.52 (PC11)
UART3_TX: R16.2, U2.4 (DI), U3.51 (PC10)
UART4_RX: J2.1, U3.15 (PA1)
UART4_TX: J2.2, U3.14 (PA0)
UART5_RX: J3.1, U3.54 (PD2)
UART5_TX: J3.2, U3.53 (PC12)
UART6_RX: U3.38 (PC7)
UART6_TX: U3.37 (PC6)
VDD: C11.1, C14.1, C18.1, C23.1, MES1.2 (+), Q3.2 (D), U4.7 (VIN), U6.2 (Vin), U10.7 (VIN), U12.7 (VIN)
Victim_LED: J16.2, U3.39 (PC8)

Notes on the sheet:
POWER
STM32F446RE
ハイサイドスイッチ＆逆流保護
STS3032
(R3+R4)/R4=8.88
低電圧防止 11.1V以下で強制遮断
Bumper
電圧計
逆接保護

Board: 2 copper layers, 79.9 x 99.9 mm, 116 parts (91 on the bottom side), 79 nets.

File 01-kanto/01-MAIN/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,SolderWire-0.75sqmm_1x02_P7mm_D1.25mm_OD3.5mm,1,Battery,
BZ1,Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm,1,Buzzer,
C1,0402,1,4n7,C1538
"C10, C16, C17, C2, C3, C4, C5, C6, C7, C9",0402,10,100n,C1525
"C11, C15, C18, C23",0805,4,10u,C15850
"C12, C19, C24",0402,3,10n,C15195
"C13, C20, C25",CP_Radial_D6.3mm_P2.50mm,3,220u,
"C14, C21, C22",0805,3,22u,C45783
C8,0402,1,4.7u,C23733
"D10, D13, D14",D_SMA,3,SS34,C8678
D11,0805,1,LED_GREEN,C2297
D12,0805,1,LED_YELLOW,C2296
D2,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,1,WS2812B,
F1,FUSE_3557-15,1,10A,
J1,JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,1,LiDAR,
J10,JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,1,Loadcell_L,
J11,JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,1,Loadcell_R,
"J12, J7",Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,2,STS3032_F,
"J13, J8",Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal,2,STS3032_B,
J14,PinHeader_1x03_P2.54mm_Horizontal,1,MG90S_L,
J15,PinHeader_1x03_P2.54mm_Horizontal,1,MG90_R,
J16,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,Victim_LED,
J2,Grove_1x04,1,CAM_L,
J3,Grove_1x04,1,CAM_R,
J4,JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal,1,CAM_LED_L,
J5,JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal,1,CAM_LED_R,
J6,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,USB_C_Receptacle_USB2.0_16P,C2765186
J9,JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,1,RPi,
"L1, L2, L3",FXL1040-220-M,3,22uH,C177244
MES1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Voltmeter_DC,
"Q1, Q2, Q3, Q5",TO-251-3_Vertical,4,Q_PMOS_GDS,
Q6,SOT-23,1,NPN,C7420356
Q7,SOT-23,1,PNP,C41375129
"R1, R2",0402,2,100k,C25741
"R10, R12, R13, R14, R18, R36, R38, R39, R43, R5, R7",0402,11,10k,C25744
"R11, R15, R19, R37, R42",0402,5,2k2,C25879
R16,0603,1,7k5,C23234
R17,0402,1,20k,C25765
R20,0603,1,1k2,C22765
R21,0402,1,1k,C11702
"R22, R30, R31, R32, R33",0402,5,330,C25104
R23,0402,1,10,C25077
"R24, R26",0402,2,5.1k,C25905
"R25, R27",0603,2,470,C23179
"R28, R29, R34, R35",0402,4,1M,C26083
R3,0603,1,13k,C22797
R4,0603,1,1k8,C4177
R40,0603,1,2.7k,C13167
SW1,AkizukiSmallRockerSwitchHorizontal,1,SW_SPST,
"SW2, SW6, SW7",SW_PUSH_6mm,3,SW_Push,
SW5,Akizuki_3PSW,1,SW_SPDT,
U1,M51957B,1,M51957B,
"U10, U12, U4",TI_SO-PowerPAD-8_ThermalVias,3,TPS5430DDA,C9864
U11,SOT-223-3_TabPin2,1,AMS1117-3.3,C6186
U2,SOIC-8_3.9x4.9mm_P1.27mm,1,MAX485E,
U3,LQFP-64_10x10mm_P0.5mm,1,STM32F446RETx,
U5,SSD1306,1,SSD1306,
U6,OKL-T6-W12N-C-SMD,1,OKL-T/6-W12N-C,
U7,BNO055,1,BNO055,
U8,MSOP-10_3x3mm_P0.5mm,1,CH340E,C99652
U9,SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm,1,LM358,C7950

## KiCad design 01-kanto/02-BOTTOM/02-BOTTOM.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 100n; C_0402_1005Metric; LCSC C1525
C9: 4.7u; C_0603_1608Metric; LCSC C19666
C11, C12: 22u; C_0805_2012Metric; LCSC C45783
D1, D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D3, D5: LED_GREEN; LED_0805_2012Metric; LCSC C2297
D4: LED_YELLOW; LED_0805_2012Metric; LCSC C2296
J2: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC C2765186
R1, R3: 5.1k; R_0402_1005Metric; LCSC C25905
R2, R4, R9: 470; R_0603_1608Metric; LCSC C23179
R5, R6, R7, R8: 10k; R_0402_1005Metric; LCSC C25744
SW1, SW2: SW_Push; TVBP06_SW
U1: S9706
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm; LCSC C8734
U4: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652
U5: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186

Connections:
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C12.1, R7.2, R8.2, SW2.1, U1.2 (VDD), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U5.2 (VO)
+5V: C2.2, C11.1, D1.1 (VDD), D2.1 (VDD), D5.2 (A), J2.1, U4.7 (VCC), U5.3 (VI)
BOOT0: R6.1, SW2.2, U3.44 (BOOT0)
CS_CK: U1.5 (CK), U3.40 (PB4)
CS_Dout: U1.1 (Dout), U3.45 (PB8)
CS_Gate: U1.6 (Gate), U3.39 (PB3)
CS_Range: U1.4 (Range), U3.41 (PB5)
D+: J3.A6 (D+), J3.B6 (D+), U4.1 (UD+)
D-: J3.A7 (D-), J3.B7 (D-), U4.2 (UD-)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, D1.3 (VSS), D2.3 (VSS), J2.4, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), R1.1, R2.2, R3.1, R4.2, R5.2, R6.2, R9.2, SW1.1, U1.3 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.3 (GND), U5.1 (GND)
LED: D1.4 (DIN), U3.5 (PD0)
NRST: C3.1, SW1.2, U3.7 (NRST)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D3.2 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: D3.1 (K), R2.1
unnamed: D4.2 (A), U4.6 (TNOW)
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R9.1
unnamed: J3.A5 (CC1), R3.2
unnamed: J3.B5 (CC2), R1.2
unnamed: R5.1, U3.20 (PB2)
unnamed: C1.1, U4.10 (V3)
SCL: R7.1, U3.42 (PB6)
SDA: R8.1, U3.43 (PB7)
UART1_RX: U3.31 (PA10), U4.8 (TXD)
UART1_TX: U3.30 (PA9), U4.9 (RXD)
UART2_RX: J2.2, U3.13 (PA3)
UART2_TX: J2.3, U3.12 (PA2)

Notes on the sheet:
WRITER

Board: 2 copper layers, 44.0 x 25.0 mm, 33 parts (30 on the bottom side), 28 nets.

File 01-kanto/02-BOTTOM/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5, C6, C7, C8",0402,8,100n,C1525
"C11, C12",0805,2,22u,C45783
C9,0603,1,4.7u,C19666
"D1, D2",LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,2,WS2812B,
"D3, D5",0805,2,LED_GREEN,C2297
D4,0805,1,LED_YELLOW,C2296
J2,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,1,Conn_01x04,
J3,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,USB_C_Receptacle_USB2.0_16P,C2765186
"R1, R3",0402,2,5.1k,C25905
"R2, R4, R9",0603,3,470,C23179
"R5, R6, R7, R8",0402,4,10k,C25744
"SW1, SW2",TVBP06_SW,2,SW_Push,
U1,S9706,1,~,
U3,LQFP-48_7x7mm_P0.5mm,1,STM32F103C8Tx,C8734
U4,MSOP-10_3x3mm_P0.5mm,1,CH340E,C99652
U5,SOT-223-3_TabPin2,1,AMS1117-3.3,C6186

## Code that names these connections

File 01-kanto/pin/01-MAIN/01-MAIN.ioc (part):

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Mcu.Name=STM32F446R(C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F446RETx
PA0-WKUP.Signal=UART4_TX
PA1.Signal=UART4_RX
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA12.Signal=GPIO_Input
PA13.Signal=GPIO_Input
PA14.Signal=GPIO_Output
PA15.Signal=GPXTI15
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA8.Signal=GPIO_Output
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB5.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB9.Signal=S_TIM11_CH1
PC10.Mode=Asynchronous
PC10.Signal=USART3_TX
PC11.Mode=Asynchronous
PC11.Signal=USART3_RX
PC12.Mode=Asynchronous
PC12.Signal=UART5_TX
PC6.Mode=Asynchronous
PC6.Signal=USART6_TX
PC7.Mode=Asynchronous
PC7.Signal=USART6_RX
PC8.Signal=GPIO_Output
PC9.Signal=S_TIM3_CH4
PD2.Mode=Asynchronous
PD2.Signal=UART5_RX
board=custom

## Commit log

2025-09-24 03-PWR 逆接防止・スイッチ・逆流防止
2025-09-25 integrated ui with pwr
2025-09-27 基板は2枚だけさ
2025-10-01 SSD1306 3dmodel
2025-10-02 02-BOTTOM schematic completed
2025-10-03 02-BOTTOM placed parts
2025-10-05 02-BOTTOM PCBdesign completed
2025-10-12 フットプリント途中
2025-10-14 配置した
2025-10-18 01-MAIN, 02-BOTTOM, 04-RPi totally completed
